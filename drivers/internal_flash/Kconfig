## drivers/internal_flash/Kconfig
```kconfig
config INTERNAL_FLASH
    bool "Internal Flash Module"
    default y

config INTERNAL_FLASH_LOG_LEVEL
    int "Log level"
    default 3
```
